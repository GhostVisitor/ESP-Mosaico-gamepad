// ===================================================================================
// 按键扫描 + 消抖 —— 实现
// ===================================================================================

#include "ch554.h"
#include "keypad.h"

// 每个按键的消抖计数器
static __xdata uint8_t kp_cnt[KP_COUNT];
// 已确认的稳定状态(bit=1 表示按下)
static uint16_t kp_state = 0;

// -----------------------------------------------------------------------------------
// 初始化:把 12 个按键引脚设为内部上拉输入
//   准双向口(Pn_MOD_OC=1, Pn_DIR_PU=1) = 开漏输出 + 内部上拉,可当输入用
//   同时把端口锁存器相应位写 1(否则弱上拉不生效,读回来永远是 0)
//   P1.0..P1.7 全部用作按键;P3 只用 bit2..bit5,不动 P3.0/P3.1/P3.6/P3.7
// -----------------------------------------------------------------------------------
void KP_init(void) {
  uint8_t i;

  P1_MOD_OC |= 0xFF;        // P1 全部:开漏 + 上拉
  P1_DIR_PU |= 0xFF;
  P3_MOD_OC |= 0x3C;        // P3.2..P3.5:开漏 + 上拉
  P3_DIR_PU |= 0x3C;

  P1 |= 0xFF;               // 锁存器置 1,启用上拉(才能作输入读取)
  P3 |= 0x3C;

  for (i = 0; i < KP_COUNT; i++) kp_cnt[i] = 0;
  kp_state = 0;
}

// -----------------------------------------------------------------------------------
// 读取原始键位(不做消抖),1 = 按下(低电平)
//   P1 低 8 位 -> bit0..bit7
//   P3.2..P3.5 -> bit8..bit11(整体左移 6 位)
// -----------------------------------------------------------------------------------
static uint16_t kp_raw(void) {
  uint16_t raw;
  raw  = (uint16_t)((uint8_t)(~P1));                    // bit0..bit7
  raw |= (uint16_t)(((uint8_t)(~P3)) & 0x3C) << 6;      // bit8..bit11
  return raw;
}

// -----------------------------------------------------------------------------------
// 读取并消抖
// -----------------------------------------------------------------------------------
uint16_t KP_read(void) {
  uint16_t raw = kp_raw();
  uint8_t  i;

  for (i = 0; i < KP_COUNT; i++) {
    uint16_t bit = (uint16_t)1 << i;

    if ((raw & bit) == (kp_state & bit)) {
      kp_cnt[i] = 0;                          // 与当前稳定值一致 -> 计数清零
    } else if (++kp_cnt[i] >= KP_DEBOUNCE_TICKS) {
      kp_state ^= bit;                        // 连续多次不一致 -> 翻转稳定状态
      kp_cnt[i] = 0;
    }
  }
  return kp_state;
}
